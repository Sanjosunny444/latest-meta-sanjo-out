IMAGE_INSTALL:append = " i2c-tools"
IMAGE_INSTALL:append = " kernel-devsrc"
IMAGE_INSTALL:append = " dtc"
IMAGE_INSTALL:append = " gcc make binutils"
IMAGE_INSTALL:append = " bmp280"
IMAGE_INSTALL:append = " paho-mqtt-c paho-mqtt-c-dev"
IMAGE_INSTALL:append = " libmodbus libmodbus-dev"
IMAGE_INSTALL:append = " sqlite3 libsqlite3-dev"
IMAGE_INSTALL:append = " telemetry-daemon"
IMAGE_INSTALL:append = " ntp"
IMAGE_INSTALL:append = " tzdata"
DEFAULT_TIMEZONE = "Asia/Kolkata"
